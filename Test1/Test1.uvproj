# Keil uVision project Test1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6ZXR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x00000000-0x0003FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Test1
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s main.c sum3.s
